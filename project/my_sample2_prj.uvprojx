# Keil uVision project my_sample2_prj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: my_sample2_prj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,RTE_CMSIS_RTOS_RTX,
  c include: ..\freertos_code\include;..\freertos_code\portable\RVDS\ARM_CM3;..\fwlib\CMSIS\Core\Include;..\fwlib\StdPeriph_Driver\inc;..\user;..\fwlib\CMSIS\device\Include;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group freertos_code
    ../freertos_code/portable/MemMang/: heap_4.c
    ../freertos_code/portable/RVDS/ARM_CM3/: port.c
    ../freertos_code/: list.c queue.c tasks.c event_groups.c timers.c
  group user
    ../user/: FreeRTOSConfig.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h debugprint.c adc.c tim.c led.c task2.c
  group cmsis
    ../fwlib/CMSIS/Core/: core_cm3.c
    ../fwlib/CMSIS/device/Source/: system_stm32f10x.c
  group fwlib
    ../fwlib/StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c
  group startup
    ../fwlib/CMSIS/device/Source/ARM/: startup_stm32f10x_hd.s
